# Keil uVision project I2C_SSD1306.uvprojx, settings and files
target Target_1 (6220000::V6.22::ARMCLANG)
  device: STM32F446RETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 DSP CLOCK(12000000) ELITTLE
  output: I2C_SSD1306
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group Source Group 1
    ./: I2C.c I2C.h conf.c conf.h ssd1306_fonts.c ssd1306_fonts.h ssd1306.c ssd1306.h main.c
software components: CMSIS:CORE 6.1.0, Device:Startup 2.6.3
